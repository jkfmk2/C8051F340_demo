# Keil uVision project C8051_Sample.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: C8051_Sample
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Code/: main.c STARTUP.A51 Int.c hwi2c.c Flash.c
